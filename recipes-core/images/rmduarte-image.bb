# Imagem file to Configure raspberry Pi 4 Model B
# Rodrigo M. Duarte                      JAN 2022
#

require recipes-core/images/rpi-test-image.bb

#IMAGE_INSTALL += " libgpiod libgpiod-tools "
